SRC_URI += "file://user_2018-10-19-13-18-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

