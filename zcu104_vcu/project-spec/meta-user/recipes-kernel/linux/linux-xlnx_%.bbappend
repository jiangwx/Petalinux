SRC_URI += "file://user_2018-10-21-18-30-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

