SRC_URI += "file://bsp.cfg \
            file://user_2018-09-21-22-52-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
