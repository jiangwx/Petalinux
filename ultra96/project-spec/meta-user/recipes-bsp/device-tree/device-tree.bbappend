SRC_URI_append ="\
    file://system-user.dtsi \
    file://xlnk.dtsi \
"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
